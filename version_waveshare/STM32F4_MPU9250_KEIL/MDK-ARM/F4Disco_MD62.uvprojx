# Keil uVision project F4Disco_MD62.uvprojx, settings and files
target migrate (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MD62IMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,STM32F40_41xxx,EMPL_TARGET_STM32F4
  c include: ..\User\inc;..\User\src;..\Peripheral\inc;..\Peripheral\src;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_StdPeriph_Driver\src;..\DeviceSupport\inc;..\DeviceSupport\src;..\core\driver\include;..\core\driver\eMPL;..\core\driver\stm32l;..\core\mllite;..\core\mpl;..\core\eMPL-hal;..\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core/driver/eMPL
    ../core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group core/driver/stm32L
    ../core/driver/stm32L/: log_stm32.c
  group core/eMPL-hal
    ../core/eMPL-hal/: eMPL_outputs.c
  group core/mllite
    ../core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group core/mpl
    ../core/mpl/: libmpllib.lib
  group DeviceSupport
    ../DeviceSupport/src/: board-st_discovery.c stm32f4_discovery.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
  group Peripheral
    ../Peripheral/src/: gpio.c i2c.c uart.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/src/: main.c
